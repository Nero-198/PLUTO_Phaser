# Repository Nero-198/PLUTO_Phaser

## KiCad design PLUTO_SDR_Beam_former/kicad/MAPS-010143.kicad_pcb

File PLUTO_SDR_Beam_former/README.md:

# RP2040-Zero 2-channel RF frontend controller

RP2040-Zeroから2チャネルのPE4302アッテネータ、MAPS-010144位相器、
BGB741 LNA、TPS7A2033/LM2776電源をUSB CDCで安全に制御するC11ファームウェアです。

安全仕様、GPIO割り当て、通信コマンドは
[`docs/hardware_interface.md`](docs/hardware_interface.md)、検証済みツールチェーンは
[`docs/BUILD_ENVIRONMENT.md`](docs/BUILD_ENVIRONMENT.md)を参照してください。

## 構成

- `firmware/include`: GPIO、共通型、I/O抽象化、時間定数
- `firmware/drivers`: SN74HC595、PE4302、MAPS-010144、BGB741、TPS7A2033
- `firmware/app`: RF電源状態機械と通信安全監視
- `firmware/protocol`: ASCII行コマンドの解析と応答
- `firmware/transport`: USB CDCの非ブロッキング入出力
- `tests`: ハードウェア非依存のコード列、波形、状態遷移、通信異常試験

GPIO0/1のUART0は現在使用せず、入力・プルなしの将来予約です。

## ホスト単体試験

```powershell
cmake -S . -B build/host -DBUILD_TESTING=ON -DRF_BUILD_PICO=OFF
cmake --build build/host --config Release
ctest --test-dir build/host -C Release --output-on-failure
```

## RP2040ファームウェアのビルド

Raspberry Pi Pico SDK、ARM GNU Toolchain、Ninja、picotoolを用意します。
標準SDKでpicotoolが有効な場合:

```powershell
$env:PICO_SDK_PATH = "C:\path\to\pico-sdk"
cmake -S . -B build/pico -G Ninja -DRF_BUILD_PICO=ON -DPICO_BOARD=pico
cmake --build build/pico
```

SDK側を`PICO_NO_PICOTOOL=1`にした場合は、UF2を必ず現在のELFから作るため、
picotoolを明示します。

```powershell
cmake -S . -B build/pico -G Ninja `
  -DRF_BUILD_PICO=ON -DPICO_BOARD=pico -DPICO_NO_PICOTOOL=1 `
  -DRF_PICOTOOL_EXECUTABLE="C:\path\to\picotool.exe"
cmake --build build/pico
```

生成物は`build/pico/rf_frontend_firmware.uf2`です。BOOTSELモードの`RPI-RP2`
ドライブへコピーすると再起動し、USB CDCとして列挙します。

検出、コピー、CDC再列挙は次のスクリプトでも確認できます。

```powershell
.\tools\flash_uf2.ps1
```

## 最小動作確認

CDCポートを開いたまま、RF電源ON中は2秒以内に`KEEPALIVE`または別の有効コマンドを
送り続けてください。最初はRF入力を外し、LNA OFF、電流制限付き電源で確認します。

```text
PING
STATUS
POWER ON
ATT ALL 31.5
PHASE ALL 0
LNA ALL OFF
KEEPALIVE
STATUS
POWER OFF
```

USB切断または2秒無通信では安全停止後にFAULTがラッチされます。再開は
`FAULT CLEAR`、`POWER ON`の順です。`POWER ON`後もLNAは自動ONになりません。
実機検証コマンドと測定記録表は
[`docs/HARDWARE_VALIDATION.md`](docs/HARDWARE_VALIDATION.md)を参照してください。

Parts:
C1, C8: 100ｐ; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C2, C21, C23, C24, C26, C29: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4, C5, C6: 33p; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C9, C10, C15, C16, C18, C19, C20, C22: 1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C11, C12: 10n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C13, C14, C17, C25, C27, C28, C30: 100n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
IC1: LM2776DBVT; SOT95P280X145-6N; Manufacturer_Part_Number LM2776DBVT
IC2, IC6: PE4302-51; QFN50P400X400X80-21N-D; Manufacturer_Part_Number PE4302-51
IC3, IC4: BGB_741L7ESD_E6327; BGB741L7ESDE6327; Manufacturer_Part_Number BGB 741L7ESD E6327
IC5: TPS7A2033PDBVR; SOT95P280X145-5N; Manufacturer_Part_Number TPS7A2033PDBVR
IC7, IC8: SN74HC595NSR; SOIC127P780X200-16N; Mouser Part Number 595-SN74HC595NSR
IC9, IC11: MAPS-010144-TR0500; QFN50P400X400X100-25N-D; Manufacturer_Part_Number MAPS-010144-TR0500
J1: Conn_01x04_Socket; TerminalBlock_Phoenix_MKDS-1,5-4-5.08_1x04_P5.08mm_Horizont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
J2, J13: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
J5, J6, J7, J8, J9, J14: Conn_Coaxial; SMA_Samtec_SMA-J-P-H-ST-EM1_EdgeMount
J15: Conn_01x04_Pin; PinSocket_1x04_P2.54mm_Vertical
JP10, JP11: Jumper_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
L1, L2, L3, L4: 22n; L_0402_1005Metric
R1, R2, R5, R6, R7, R12: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: open or 3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: dummper; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R11, R18, R19, R20, R21, R22, R23, R24: 33; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R14: 10k; R_0402_1005Metric
R15: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R17: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_1.0x1.0mm
U3: RP2040-Zero; RP2040-Zero-THT

Connections:
3V3: C1.1, C8.1, C10.2, C13.2, C14.2, C15.1, C16.1, C18.1, C19.1, C20.2, C21.2, C26.2, C27.2, C29.2, C30.2, IC1.3 (VIN), IC2.6 (VDD_1), IC2.7 (PUP1), IC2.8 (PUP2), IC2.9 (VDD_2), IC3.1 (VCC), IC4.1 (VCC), IC5.5 (OUT), IC6.6 (VDD_1), IC6.7 (PUP1), IC6.8 (PUP2), IC6.9 (VDD_2), IC7.16 (VCC), IC8.16 (VCC), IC9.2 (P/S), IC9.18 (VCC), IC11.2 (P/S), IC11.18 (VCC), J1.2, L2.1, L4.1, R3.1, R4.1, R15.1
+5V: C9.2, IC5.1 (IN), J1.1, J15.1, U3.32 (5V)
/ATT_IN_1: IC2.2 (RF1), IC11.14 (RF_OUT)
/ATT_IN_2: IC6.2 (RF1), IC9.14 (RF_OUT)
/ATT_OUT_1: IC2.14 (RF2), J6.1 (In), R13.1
/ATT_OUT_2: IC6.14 (RF2), J14.1 (In), R14.1
/LNA_RF_IN_1: C3.2, IC3.3 (RF-IN), L1.2
/LNA_RF_IN_2: C5.2, IC4.3 (RF-IN), L3.2
/LNA_RF_OUT_1: C4.1, IC3.4 (RF-OUT), L2.2
/LNA_RF_OUT_2: C6.1, IC4.4 (RF-OUT), L4.2
/PHASE_IN_1: C4.2, IC11.5 (RF_IN)
/PHASE_IN_2: C6.2, IC9.5 (RF_IN)
/Test: J7.1 (In), J8.1 (In)
/signal: C5.1, J9.1 (In)
/signal_1: C3.1, J5.1 (In)
ATT_SER: IC7.14 (SER), R19.1
ATT_ch2_SER: IC8.14 (SER), R11.2
CLK_CH1: IC9.23 (D2), IC11.23 (D2), R23.2
GND: C1.2, C2.1, C8.2, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.1, C18.2, C19.2, C20.1, C21.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, IC1.2 (GND), IC2.10 (GND_1), IC2.11 (GND_2), IC2.13 (P/S), IC2.18 (GND_3), IC2.21 (EP), IC3.7 (GND), IC4.7 (GND), IC5.2 (GND), IC6.10 (GND_1), IC6.11 (GND_2), IC6.13 (P/S), IC6.18 (GND_3), IC6.21 (EP), IC7.8 (GND), IC7.13 (~OE), IC8.8 (GND), IC8.13 (~OE), IC9.3 (GND_1), IC9.4 (GND_2), IC9.6 (GND_3), IC9.7 (GND_4), IC9.8 (GND_5), IC9.9 (GND_6), IC9.10 (GND_7), IC9.11 (GND_8), IC9.12 (GND_9), IC9.13 (GND_10), IC9.15 (GND_11), IC9.16 (GND_12), IC9.25 (GND_13), IC11.3 (GND_1), IC11.4 (GND_2), IC11.6 (GND_3), IC11.7 (GND_4), IC11.8 (GND_5), IC11.9 (GND_6), IC11.10 (GND_7), IC11.11 (GND_8), IC11.12 (GND_9), IC11.13 (GND_10), IC11.15 (GND_11), IC11.16 (GND_12), IC11.25 (GND_13), J1.4, J2.2, J5.2 (Ext), J6.2 (Ext), J7.2 (Ext), J8.2 (Ext), J9.2 (Ext), J13.2, J14.2 (Ext), J15.4, JP10.2 (B), JP11.2 (B)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
LDO_ENABLE: IC5.3 (EN), U3.26
LE_CH1: IC9.22 (D3), IC11.22 (D3), R24.2
unnamed: C22.1, IC1.5 (C1+)
unnamed: C22.2, IC1.6 (C1-)
unnamed: C17.2, IC1.4 (EN), R15.2
unnamed: IC2.1 (C16), R1.1
unnamed: IC2.3 (DATA), R2.1
unnamed: IC2.12 (VSS/GND), J2.1, JP10.1 (A)
unnamed: IC3.2 (BIASOUT), L1.1
unnamed: IC3.6 (CURRENT_ADJUST), R3.2
unnamed: IC4.2 (BIASOUT), L3.1
unnamed: IC4.6 (CURRENT_ADJUST), R4.2
unnamed: IC6.1 (C16), R6.1
unnamed: IC6.3 (DATA), R5.1
unnamed: IC6.12 (VSS/GND), J13.1, JP11.1 (A)
unnamed: IC9.21 (D4), TP4.1 (1_1)
unnamed: IC9.20 (D5), TP5.1 (1_1)
unnamed: IC9.19 (D6), TP6.1 (1_1)
unnamed: C2.2, C28.2, IC9.1 (VEE), R17.2
unnamed: IC11.21 (D4), TP1.1 (1_1)
unnamed: IC11.20 (D5), TP2.1 (1_1)
unnamed: IC11.19 (D6), TP3.1 (1_1)
unnamed: C24.2, C25.2, IC11.1 (VEE), R16.2
unnamed: R8.2, U3.5
unnamed: R19.2, U3.2
unnamed: R20.2, U3.3
unnamed: R21.2, U3.4
unnamed: R22.1, U3.11
unnamed: R23.1, U3.10
unnamed: R24.1, U3.9
SER_IN_CH1: IC11.24 (D1), R22.2
SER_OUT_CH1: IC9.24 (D1), IC11.17 (SER_OUT)
UART_RX: J15.3, U3.1
UART_TX: J15.2, U3.0
ch1SRCLK: IC7.11 (SRCLK), R10.1, R20.1
ch1_ATT_C0.5: IC2.20 (C0.5), IC7.2 (QC)
ch1_ATT_C1: IC2.19 (C1), IC7.3 (QD)
ch1_ATT_C2: IC2.17 (C2), IC7.4 (QE)
ch1_ATT_C4: IC2.16 (C4), IC7.5 (QF)
ch1_ATT_C8: IC2.15 (C8), IC7.6 (QG)
ch1_ATT_C16: IC7.7 (QH), R1.2
ch1_ATT_CLK: IC2.4 (CLOCK), R7.2
ch1_ATT_LE: IC2.5 (LE), IC6.5 (LE), R8.1
ch1_LNA_ON: C11.2, IC3.5 (ON/OFF_CONTROL), U3.14
ch1_QH: IC7.9 (QH'), R11.1
ch1_RCLK: IC7.12 (RCLK), R9.1, R21.1
ch1_SRCLR: IC7.10 (~SRCLR), R18.1, U3.8
ch2_ATT_C0.5: IC6.20 (C0.5), IC8.2 (QC)
ch2_ATT_C1: IC6.19 (C1), IC8.3 (QD)
ch2_ATT_C2: IC6.17 (C2), IC8.4 (QE)
ch2_ATT_C4: IC6.16 (C4), IC8.5 (QF)
ch2_ATT_C8: IC6.15 (C8), IC8.6 (QG)
ch2_ATT_C16: IC8.7 (QH), R6.2
ch2_ATT_CLK: IC6.4 (CLOCK), R12.2
ch2_LNA_ON: C12.2, IC4.5 (ON/OFF_CONTROL), U3.15
ch2_RCLK: IC8.12 (RCLK), R9.2
ch2_SRCLK: IC8.11 (SRCLK), R10.2
ch2_SRCLR: IC8.10 (~SRCLR), R18.2
ー3V3: C23.2, IC1.1 (VOUT), J1.3, R16.1, R17.1

Notes on the sheet:
パラレル固定
INPUT
PUP1, PUP2 = (1,1) 起動時減衰最大
LNA
GND = 内部負電源 -VDD = 外部電源
パラレルでは使わない。clkは10kを挿入する。
50Ω
P/S = 0 パラレル P/S = 1 シリアル
-3.3V電源 MAPS-010144で使う
シリアルモードで利用する
ダンパー抵抗
33pFで良いのかは分からん。
SER :値を入力するデータピン。このpinの値がレジスタに取り込まれる。 OE :出力イネーブルピン。0で出力ON 1で出力OFF RCLK :ストレージレジスタに出力が送られる。 SRCLK :シフトレジスタクロック SRCLR :シフトレジスタクリア端子。0でクリアされる。
可変アッテネータ 0.5bB step 31.5dB 0-4GHz
どっちもRF入出力は双方向
C20はLM2776の近くに！
nominal frequency band of 1.7-2.2 GHz 1.1-3.0 GHz for narrow
RF1,RF2はDC0Vを入力すること
S/P = 0 パラレル S/P = 1 シリアル パラレル： P0...P7 シリアル： A0...A3 LEO, CLK, SDO1 SDO2
MAX:3.3V MIN:2.7V
パラレルモードで利用する。 データはシフトレジスタによって送る。

Board: 4 copper layers, 49.1 x 82.8 mm, 86 parts (18 on the bottom side), 78 nets.

## Commit log (part)

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2026-05-04 new feature 2ch MAPS
2026-05-04 v2 発注記念。
2026-05-13 色々指摘もらったので修正して発注する。
